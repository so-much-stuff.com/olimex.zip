# EAGLE board olimex (EAGLE 4.11), part 2 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DIO07  (via drill 0.61)  (2 unrouted) (continued)
  Top 0.254: v77.47,54.61 76.83,55.24 76.83,63.5 77.47,64.14 77.47,116.84 78.73,118.11 IC15.12 | SV1.16 30.48,10.79 31.75,12.06 31.75,16.51 32.38,17.14 32.38,41.27 31.11,42.55 31.11,50.16 IC26.11 | v45.71,52.07 v45.71,35.56 | RF08A.30 273.68,58.42 273.05,57.78 273.05,53.98 274.31,52.7 274.31,46.99 IC42.18 | IC39.18 274.31,113.03 273.05,114.3 273.05,122.56 274.31,123.83 RF08B.30
  Bottom 0.254: IC26.11 31.75,50.8 33.02,52.07 v45.71,52.07 57.78,52.07 59.05,53.34 64.77,53.34 IC28.9 67.31,53.34 68.58,53.34 69.84,54.61 v77.47,54.61 | v45.71,35.56 41.27,35.56 RS08.30
DIO08  (via drill 0.61)  (2 unrouted)
  Top 0.254: v43.17,54.61 v43.17,49.53 v43.17,33.02 43.17,22.23 41.9,20.95 41.9,15.24 v40.63,13.97 | v69.21,117.47 68.58,116.84 68.58,64.14 67.94,63.5 67.94,60.96 70.48,58.42 v70.48,52.07 | v33.02,13.97 33.02,10.79 SV1.18 | RF08A.32 276.22,58.42 275.58,57.78 275.58,53.98 276.86,52.7 276.86,46.99 IC42.17 | IC39.17 276.86,113.03 275.58,114.3 275.58,122.56 276.86,123.83 RF08B.32
  Bottom 0.254: v43.17,54.61 29.21,54.61 27.94,55.88 24.12,55.88 IC26.8 | v43.17,33.02 41.27,33.02 RS08.32 | v43.17,49.53 48.25,49.53 48.89,48.9 49.52,48.9 50.79,50.16 57.14,50.16 59.05,52.07 v70.48,52.07 71.12,52.07 72.39,53.34 IC28.12 | v69.21,117.47 69.84,116.84 78.73,116.84 80.64,118.75 IC15.11 | v33.02,13.97 v40.63,13.97
DIO09  (via drill 0.61)  (2 unrouted)
  Top 0.254: v27.3,33.02 27.3,29.21 26.67,28.57 26.67,6.35 36.19,6.35 36.82,6.99 36.82,8.26 35.55,9.53 SV1.20 | v78.1,59.69 78.1,62.23 82.55,66.67 82.55,116.84 83.81,118.11 IC15.10 | v18.41,36.83 17.14,38.1 v17.14,59.05 | RF08A.29 274.95,55.88 274.95,47.62 275.58,46.99 275.58,43.81 274.31,42.55 274.31,31.75 IC42.15 | IC39.15 274.31,97.79 275.58,99.06 275.58,113.03 274.31,114.3 274.31,121.28 RF08B.29
  Bottom 0.254: v27.3,33.02 28.57,34.29 32.38,34.29 | 32.38,34.29 35.55,34.29 36.82,35.56 37.46,35.56 RS08.29 | v78.1,59.69 76.83,58.42 74.93,58.42 IC28.14 72.39,58.42 71.12,58.42 69.84,57.15 37.46,57.15 34.92,59.69 29.21,59.69 28.57,60.33 24.76,60.33 24.12,60.96 IC26.6 21.59,60.96 19.05,60.96 v17.14,59.05 | 32.38,34.29 32.38,36.83 v18.41,36.83
DIO10  (via drill 0.61)  (2 unrouted)
  Top 0.254: v19.68,66.04 20.32,65.41 20.32,46.35 v19.68,45.72 | v35.55,45.72 36.82,44.45 36.82,42.55 37.46,41.91 36.82,41.27 36.82,40.01 | 36.82,40.01 38.09,38.73 RS08.27 | v67.31,45.09 71.75,49.53 71.75,61.59 73.02,62.87 IC28.16 | v85.09,84.45 85.09,116.84 86.36,118.11 IC15.9 | v80.64,83.19 78.1,80.64 v78.1,63.5 | 36.82,40.01 36.82,22.23 37.46,21.59 37.46,11.43 38.09,10.79 SV1.22 | RF08A.27 272.41,55.88 272.41,47.62 273.05,46.99 273.05,43.81 271.77,42.55 271.77,31.75 IC42.14 | IC39.14 271.77,97.79 273.05,99.06 273.05,113.03 271.77,114.3 271.77,121.28 RF08B.27
  Bottom 0.254: v19.68,66.04 21.59,66.04 IC26.4 | v19.68,45.72 v35.55,45.72 36.82,44.45 41.27,44.45 41.9,43.81 66.04,43.81 v67.31,45.09 | v85.09,84.45 83.81,83.19 v80.64,83.19 | v78.1,63.5 74.93,63.5 IC28.16
DIO11  (via drill 0.61)  (2 unrouted)
  Top 0.254: 33.02,64.77 33.02,52.07 34.28,50.8 v34.28,42.55 | 33.02,64.77 v33.02,67.94 | v70.48,66.04 70.48,66.67 72.39,68.58 IC28.18 73.02,69.22 70.48,71.75 70.48,89.53 72.39,91.44 v72.39,99.06 | 33.02,64.77 v33.65,64.77 | v90.17,99.69 90.17,116.84 88.9,118.11 IC15.8 | v46.98,38.1 46.98,6.35 42.54,6.35 41.9,6.99 41.9,8.26 40.63,9.53 SV1.24 | RF08A.25 269.87,55.88 269.87,47.62 270.5,46.99 270.5,43.81 269.24,42.55 269.24,31.75 IC42.13 | IC39.13 269.24,97.79 270.5,99.06 270.5,113.03 269.24,114.3 269.24,121.28 RF08B.25
  Bottom 0.254: v33.02,67.94 32.38,67.31 27.94,67.31 24.12,71.12 IC26.2 | v34.28,42.55 36.19,40.64 37.46,40.64 RS08.25 38.73,40.64 40,39.37 45.71,39.37 v46.98,38.1 | v70.48,66.04 69.21,64.77 v33.65,64.77 | v90.17,99.69 89.53,99.06 v72.39,99.06
DIOEVEN  (via drill 0.61)  (2 unrouted)
  Top 0.254: v45.71,30.48 v45.71,26.67 | v60.32,114.94 62.22,113.03 62.22,92.08 60.32,90.17 60.32,40.64 61.59,39.37 61.59,23.5 64.77,20.32 IC35.9 | v287.01,88.9 285.75,90.17 285.75,125.09 285.11,125.73 279.39,125.73 279.39,125.09 RF08B.34
  Bottom 0.254: v45.71,26.67 59.68,26.67 65.4,20.95 IC35.9 | v45.71,30.48 41.27,30.48 RS08.34 | v60.32,114.94 59.68,114.3 46.98,114.3 46.35,114.94 24.76,114.94 20.95,118.75 IC13.13 | IC43.18 274.95,22.23 276.22,23.5 286.38,23.5 287.01,22.86 298.44,22.86 304.16,28.57 304.16,59.69 281.3,59.69 280.03,58.42 RF08A.34 | v287.01,88.9 276.86,88.9 274.95,87 IC45.18
DMA00  (via drill 0.61)  (2 unrouted)
  Top 0.254: v137.16,11.43 135.88,10.16 DMA0-3.7 133.98,9.53 128.9,4.45 v128.9,3.17 | 46.98,54.61 v45.71,53.34 | 46.98,54.61 v46.98,86.36 | v43.17,90.17 43.17,87 SV2.1 | v73.66,6.99 60.32,20.32 v60.32,39.37 | v47.62,39.37 46.98,40.01 46.98,54.61 | IC43.25 256.54,22.86 256.54,27.3 255.27,28.57 255.27,31.75 256.54,33.02 256.54,44.45 IC42.25 256.54,46.99 256.54,52.7 255.27,53.98 255.27,57.78 255.9,58.42 RF08A.16 | IC45.25 256.54,87.63 255.27,88.9 255.27,107.95 256.54,109.22 256.54,110.49 IC39.25 256.54,113.03 255.27,114.3 255.27,122.56 256.54,123.83 RF08B.16
  Bottom 0.254: v137.16,11.43 162.56,11.43 163.83,12.7 IC38.8 | v45.71,53.34 41.27,53.34 RS08.16 | v46.98,86.36 43.81,86.36 SV2.1 | v43.17,90.17 35.55,90.17 33.65,88.27 19.05,88.27 19.05,85.72 18.41,85.09 17.14,85.09 15.87,83.82 SV2.24 | v128.9,3.17 128.27,2.54 96.52,2.54 93.98,5.08 78.1,5.08 77.47,4.45 76.2,4.45 v73.66,6.99 | v60.32,39.37 v47.62,39.37
DMA01  (via drill 0.61)  (2 unrouted)
  Top 0.254: 40.63,80.64 39.36,79.38 39.36,50.16 40.63,48.9 RS08.20 | 40.63,80.64 40.63,81.92 39.36,83.19 39.36,84.45 40.63,85.72 SV2.3 | v92.7,11.43 90.17,13.97 v90.17,44.45 | v57.78,79.38 v57.78,45.72 | 40.63,80.64 v41.9,79.38 | IC43.23 261.62,22.86 261.62,27.3 260.35,28.57 260.35,31.75 261.62,33.02 261.62,44.45 IC42.23 261.62,46.99 261.62,52.7 260.35,53.98 260.35,57.78 260.98,58.42 RF08A.20 | IC45.23 261.62,87.63 260.98,88.27 260.98,94.61 260.35,95.25 260.35,106.05 261.62,107.31 261.62,110.49 IC39.23 261.62,113.03 260.35,114.3 260.35,122.56 261.62,123.83 RF08B.20
  Bottom 0.254: IC38.6 163.83,17.78 162.56,16.51 139.69,16.51 135.88,12.7 DMA0-3.6 133.34,12.7 110.48,12.7 109.22,11.43 v92.7,11.43 | v90.17,44.45 69.21,44.45 67.31,46.35 58.41,46.35 v57.78,45.72 | v41.9,79.38 v57.78,79.38
DMA02  (via drill 0.61)  (2 unrouted)
  Top 0.254: v49.52,55.88 v49.52,88.9 | v40.63,91.44 38.09,88.9 38.09,87 SV2.5 | v132.71,19.05 132.71,20.95 133.98,22.23 DMA0-3.2 | v84.45,20.32 80.64,24.13 v80.64,57.15 | IC43.26 254,22.86 254,27.3 252.72,28.57 252.72,31.75 254,33.02 254,44.45 IC42.26 254,46.99 254,52.7 252.72,53.98 252.72,57.78 253.36,58.42 RF08A.14 | IC45.26 254,87.63 252.72,88.9 252.72,109.22 254,110.49 IC39.26 254,113.03 252.72,114.3 252.72,122.56 254,123.83 RF08B.14
  Bottom 0.254: DMA0-3.2 135.88,22.86 137.16,21.59 162.56,21.59 163.83,22.86 IC38.4 | v49.52,88.9 46.98,91.44 v40.63,91.44 | RS08.14 41.27,55.88 v49.52,55.88 50.79,54.61 68.58,54.61 71.12,57.15 v80.64,57.15 | v132.71,19.05 132.08,18.41 94.61,18.41 92.7,20.32 v84.45,20.32
DMA03  (via drill 0.61)  (2 unrouted)
  Top 0.254: v139.06,29.21 139.06,24.77 135.25,20.95 DMA0-3.3 | v159.38,30.48 v161.92,27.94 | v48.25,85.09 v48.25,58.42 v48.25,48.26 | v93.34,21.59 90.8,24.13 90.8,43.81 91.44,44.45 91.44,45.72 v90.17,46.99 | IC43.27 251.46,22.86 251.46,27.3 250.19,28.57 250.19,31.75 251.46,33.02 251.46,44.45 IC42.27 251.46,46.99 251.46,52.7 250.19,53.98 250.19,57.78 250.82,58.42 RF08A.12 | IC45.27 251.46,87.63 250.82,88.27 250.82,94.61 250.19,95.25 250.19,98.42 251.46,99.69 251.46,110.49 IC39.27 251.46,113.03 250.19,114.3 250.19,122.56 251.46,123.83 RF08B.12
  Bottom 0.254: v139.06,29.21 140.33,30.48 v159.38,30.48 | v161.92,27.94 163.83,27.94 IC38.2 | v48.25,85.09 37.46,85.09 36.19,86.36 SV2.7 | v48.25,58.42 41.27,58.42 RS08.12 | v93.34,21.59 95.88,19.05 125.09,19.05 126.36,20.32 133.34,20.32 DMA0-3.3 | v90.17,46.99 87.62,49.53 80.01,49.53 78.1,47.62 52.7,47.62 52.06,48.26 v48.25,48.26
DMA04  (via drill 0.61)  (2 unrouted)
  Top 0.254: v35.55,60.96 35.55,78.11 34.28,79.38 v34.28,82.55 | v124.45,80.01 124.45,73.03 125.73,71.75 v125.73,64.77 | v138.43,61.59 137.79,60.96 137.79,50.16 135.88,48.26 132.71,48.26 132.71,46.35 133.98,45.09 DMA4-7.7 | IC43.5 248.91,7.62 248.91,18.41 250.19,19.68 250.19,22.86 249.55,23.5 249.55,29.84 IC42.5 249.55,31.11 249.55,32.38 250.19,33.02 250.19,46.99 249.55,47.62 249.55,55.88 RF08A.9 | IC45.5 248.91,72.39 250.19,73.66 250.19,93.98 248.91,95.25 IC39.5 248.91,97.79 248.91,98.42 250.19,99.69 250.19,113.03 249.55,113.67 249.55,120.65 248.91,121.28 RF08B.9
  Bottom 0.254: v35.55,60.96 37.46,60.96 RS08.9 | SV2.9 33.02,85.72 34.28,85.72 v34.28,82.55 38.73,78.11 60.95,78.11 64.13,81.28 93.98,81.28 95.88,83.19 97.15,83.19 97.79,82.55 97.79,79.38 120.65,79.38 121.28,80.01 v124.45,80.01 | DMA4-7.7 135.88,44.45 139.69,48.26 153.03,48.26 155.57,45.72 160.65,45.72 161.92,46.99 163.83,46.99 IC31.8 | v125.73,64.77 135.25,64.77 v138.43,61.59
DMA05  (via drill 0.61)  (2 unrouted)
  Top 0.254: v35.55,79.38 v36.82,78.11 36.82,73.03 36.19,72.39 36.19,61.59 36.82,60.96 36.82,60.33 38.09,59.05 RS08.11 | v138.43,41.91 138.43,43.18 135.25,46.35 DMA4-7.6 | v158.11,40.01 160.02,41.91 160.02,50.8 v161.28,52.07 | v62.22,78.11 61.59,77.47 61.59,44.45 63.49,42.55 v63.49,40.64 | IC43.6 251.46,7.62 251.46,18.41 252.72,19.68 252.72,22.86 252.09,23.5 252.09,29.84 IC42.6 252.09,31.11 252.09,32.38 252.72,33.02 252.72,46.99 252.09,47.62 252.09,55.88 RF08A.11 | IC45.6 251.46,72.39 252.72,73.66 252.72,87.63 251.46,88.9 251.46,95.25 IC39.6 252.09,97.16 252.09,109.86 252.72,110.49 252.72,113.03 252.09,113.67 252.09,120.65 251.46,121.28 RF08B.11
  Bottom 0.254: v35.55,79.38 31.75,83.19 31.75,84.45 30.48,85.72 SV2.11 | v138.43,41.91 140.33,40.01 v158.11,40.01 | v161.28,52.07 163.83,52.07 IC31.6 | v36.82,78.11 37.46,77.47 61.59,77.47 v62.22,78.11 | v63.49,40.64 64.77,39.37 118.74,39.37 123.82,44.45 130.81,44.45 133.34,46.99 DMA4-7.6
DMA06  (via drill 0.61)  (2 unrouted)
  Top 0.254: v19.05,55.88 18.41,56.52 18.41,59.05 16.51,60.96 v16.51,75.56 16.51,80.64 13.96,83.19 13.96,91.44 v14.6,92.08 | v117.47,59.69 116.2,60.96 v116.2,77.47 | v90.8,78.11 91.44,78.74 91.44,93.98 90.17,95.25 90.17,98.42 88.9,99.69 v88.9,100.97 | IC43.7 254,7.62 254,18.41 255.27,19.68 255.27,22.86 254.63,23.5 254.63,29.84 IC42.7 254.63,31.11 254.63,32.38 255.27,33.02 255.27,46.99 254.63,47.62 254.63,55.88 RF08A.13 | IC45.7 254,72.39 255.27,73.66 255.27,87.63 254,88.9 254,95.25 IC39.7 254,97.79 254,107.95 255.27,109.22 255.27,113.03 254.63,113.67 254.63,120.65 254,121.28 RF08B.13
  Bottom 0.254: IC31.4 163.83,57.15 162.56,55.88 137.16,55.88 135.88,57.15 DMA4-7.2 133.34,57.15 132.71,57.78 129.53,57.78 127.63,59.69 v117.47,59.69 | v19.05,55.88 20.32,55.88 21.59,57.15 36.19,57.15 37.46,55.88 RS08.13 | v16.51,75.56 24.12,83.19 24.12,85.09 26.03,85.09 27.3,86.36 SV2.13 | v116.2,77.47 115.56,78.11 v90.8,78.11 | v88.9,100.97 88.26,100.33 73.66,100.33 73.02,100.97 61.59,100.97 60.95,101.6 45.08,101.6 41.9,98.42 12.06,98.42 11.42,97.79 11.42,95.89 10.79,95.89 8.25,93.34 8.25,88.27 10.79,88.27 v14.6,92.08
DMA07  (via drill 0.61)  (2 unrouted)
  Top 0.254: v137.16,64.14 137.16,57.15 135.25,55.24 DMA4-7.3 | v36.82,49.53 36.82,51.44 38.09,52.7 RS08.15 | v113.66,45.72 117.47,49.53 v117.47,57.15 | v25.39,89.53 25.39,87 SV2.15 | v52.06,46.99 v52.06,92.71 | IC43.8 256.54,7.62 256.54,18.41 257.81,19.68 257.81,22.86 257.17,23.5 257.17,29.84 IC42.8 257.17,31.11 257.17,32.38 257.81,33.02 257.81,46.99 257.17,47.62 257.17,55.88 RF08A.15 | IC45.8 256.54,72.39 257.81,73.66 257.81,87.63 256.54,88.9 256.54,95.25 IC39.8 256.54,97.79 256.54,98.42 257.81,99.69 257.81,113.03 257.17,113.67 257.17,120.65 256.54,121.28 RF08B.15
  Bottom 0.254: v137.16,64.14 138.43,65.41 163.19,65.41 163.83,66.04 173.99,66.04 174.62,65.41 174.62,63.5 167.63,63.5 166.37,62.23 IC31.2 | v36.82,49.53 41.9,49.53 44.45,46.99 v52.06,46.99 88.9,46.99 90.17,45.72 v113.66,45.72 | v117.47,57.15 130.81,57.15 133.34,54.61 DMA4-7.3 | v25.39,89.53 28.57,92.71 v52.06,92.71
DMA08  (via drill 0.61)  (2 unrouted)
  Top 0.254: v137.79,83.82 137.79,81.92 135.25,79.38 DMA8-11.7 | v159.38,85.09 160.65,83.82 v160.65,81.28 | v33.02,50.8 32.38,50.16 v32.38,42.55 | v10.15,41.91 8.88,43.18 v8.88,81.28 | v130.81,80.64 130.17,81.28 v130.17,93.98 | v99.06,93.98 97.79,95.25 v97.79,99.06 | IC43.9 259.07,7.62 259.07,18.41 260.35,19.68 260.35,22.86 259.71,23.5 259.71,29.84 IC42.9 259.71,31.11 259.71,32.38 260.35,33.02 260.35,46.99 259.71,47.62 259.71,55.88 RF08A.17 | IC45.9 259.07,72.39 260.35,73.66 260.35,93.98 259.07,95.25 IC39.9 259.07,97.79 259.07,106.05 260.35,107.31 260.35,113.03 259.71,113.67 259.71,120.65 259.07,121.28 RF08B.17
  Bottom 0.254: v137.79,83.82 139.06,85.09 v159.38,85.09 | v160.65,81.28 163.83,81.28 IC24.8 | v33.02,50.8 37.46,50.8 RS08.17 | v32.38,42.55 31.75,41.91 v10.15,41.91 | 9.52,81.92 10.15,82.55 20.95,82.55 21.59,83.19 21.59,86.36 22.22,86.36 SV2.17 | v8.88,81.28 9.52,81.92 | v130.81,80.64 131.44,80.64 133.34,78.74 DMA8-11.7 | v99.06,93.98 v130.17,93.98 | v97.79,99.06 94.61,102.23 88.9,102.23 87.62,100.97 74.29,100.97 73.66,101.6 62.22,101.6 61.59,102.23 44.45,102.23 41.27,99.06 9.52,99.06 5.08,94.61 5.08,81.92 9.52,81.92
DMA09  (via drill 0.61)  (2 unrouted)
  Top 0.254: v136.52,85.09 136.52,83.19 135.25,81.92 DMA8-11.6 | v42.54,63.5 41.9,62.87 41.9,46.99 40,46.99 38.73,48.26 RS08.19 | v45.08,63.5 46.35,64.77 46.35,85.72 45.71,86.36 45.71,87 v46.35,87.63 | IC43.10 261.62,7.62 261.62,18.41 262.88,19.68 262.88,22.86 262.25,23.5 262.25,29.84 IC42.10 262.25,31.11 262.25,32.38 262.88,33.02 262.88,55.24 262.25,55.88 RF08A.19 | IC45.10 261.62,72.39 262.88,73.66 262.88,88.27 261.62,89.53 261.62,95.25 IC39.10 261.62,97.79 262.88,99.06 262.88,120.02 261.62,121.28 RF08B.19
  Bottom 0.254: IC24.6 163.83,86.36 162.56,86.36 161.28,87.63 139.06,87.63 v136.52,85.09 128.27,85.09 127,86.36 52.06,86.36 50.79,87.63 v46.35,87.63 20.95,87.63 20.32,87 SV2.19 | v42.54,63.5 v45.08,63.5
DMA10  (via drill 0.61)  (2 unrouted)
  Top 0.254: v6.34,46.99 v6.34,83.19 | v126.36,91.44 125.73,90.81 v125.73,84.45 | v50.79,81.92 v50.79,45.72 | 265.43,29.21 264.79,29.84 IC42.11 | 265.43,29.21 265.43,19.68 264.16,18.41 264.16,7.62 IC43.11 | 265.43,29.21 265.43,46.99 264.16,48.26 264.16,55.24 RF08A.21 | 265.43,93.98 265.43,73.66 264.16,72.39 IC45.11 | 265.43,93.98 264.16,95.25 IC39.11 | 265.43,93.98 265.43,113.03 264.79,113.67 264.79,120.65 264.16,121.28 RF08B.21
  Bottom 0.254: IC24.4 163.83,91.44 162.56,90.17 137.16,90.17 135.88,91.44 DMA8-11.2 133.34,91.44 v126.36,91.44 | 36.19,46.99 37.46,45.72 RS08.21 | 36.19,46.99 v6.34,46.99 | v6.34,83.19 8.25,85.09 15.87,85.09 17.14,86.36 SV2.21 | v125.73,84.45 100.96,84.45 100.33,83.82 99.06,83.82 97.15,85.72 54.6,85.72 v50.79,81.92 | v50.79,45.72 50.16,46.35 41.9,46.35 41.27,46.99 36.19,46.99
DMA11  (via drill 0.61)  (2 unrouted)
  Top 0.254: v161.92,96.52 v161.92,99.06 | DMA8-11.3 135.25,89.53 137.16,91.44 v137.16,98.42 130.17,105.41 130.17,108.58 128.27,110.49 128.27,120.02 v125.09,123.19 | v27.94,44.45 27.3,45.09 27.3,50.16 27.94,50.8 v27.94,58.42 | v19.05,59.69 19.05,65.41 18.41,66.04 18.41,82.55 19.05,83.19 19.05,84.45 18.41,85.09 16.51,85.09 | 16.51,85.09 15.23,85.09 15.23,85.72 SV2.23 | v16.51,126.36 16.51,85.09 | IC43.12 266.69,7.62 266.69,19.05 267.97,20.32 267.97,22.86 266.69,24.13 266.69,29.21 IC42.12 266.69,31.75 266.69,42.55 267.97,43.81 267.97,46.99 267.33,47.62 267.33,55.88 RF08A.23 | 267.97,93.98 267.97,73.66 266.69,72.39 IC45.12 | 267.97,93.98 266.69,95.25 IC39.12 | 267.97,93.98 267.97,113.03 267.33,113.67 267.33,120.65 266.69,121.28 RF08B.23
  Bottom 0.254: v137.16,98.42 161.28,98.42 v161.92,99.06 | v161.92,96.52 163.83,96.52 IC24.2 | v27.94,44.45 29.84,44.45 30.48,43.81 36.82,43.81 37.46,43.18 RS08.23 | v27.94,58.42 26.67,59.69 v19.05,59.69 | v125.09,123.19 124.45,122.56 93.34,122.56 92.7,121.92 63.49,121.92 59.05,126.36 v16.51,126.36
DMA-IN\  (via drill 0.61)
  Top 0.254: IC34.1 22.86,41.27 22.86,48.26 24.76,50.16 24.76,71.75 23.49,73.03 IC26.1 22.86,74.3 22.86,76.83 24.12,78.11 24.12,109.22 25.39,110.49 IC13.4 | v19.05,12.06 19.68,12.7 19.68,36.83 v18.41,38.1
  Bottom 0.254: IC26.19 29.21,71.12 28.57,71.75 26.03,71.75 24.12,73.66 IC26.1 | v19.05,12.06 41.27,12.06 41.9,12.7 76.83,12.7 77.47,13.34 86.99,13.34 88.26,14.61 IC41.12 | v18.41,38.1 20.95,40.64 21.59,40.64 IC34.1
DMA-OUT\  (via drill 0.61)
  Top 0.254: IC35.1 65.4,41.27 64.13,42.55 64.13,71.75 65.4,73.03 IC28.1 | 75.56,40.01 74.29,38.73 IC35.19 | 75.56,40.01 75.56,69.22 74.29,70.48 IC28.19 | v92.7,19.05 95.88,15.88 IC41.9 | v76.2,19.05 76.2,29.84 75.56,30.48 75.56,40.01
  Bottom 0.254: v76.2,19.05 v92.7,19.05 | IC28.1 67.31,73.66 69.84,71.12 72.39,71.12 IC28.19
DONE  (via drill 0.61)
  Top 0.254: v152.4,26.67 152.4,22.86 150.49,20.95 IC40.2 | v177.8,26.67 178.43,26.04 178.43,8.26 184.15,2.54 194.31,2.54 194.31,113.03 198.12,116.84 198.12,118.11 IC11.9 | v57.14,6.99 v64.77,14.61 | v132.08,15.24 133.34,13.97 139.69,13.97 139.69,10.16 140.97,8.89 145.41,8.89 145.41,19.68 v146.05,20.32
  Bottom 0.254: v152.4,26.67 v177.8,26.67 | v57.14,6.99 50.79,6.99 50.16,6.35 42.54,6.35 41.27,7.62 SV1.23 | v64.77,14.61 66.67,16.51 69.84,16.51 72.39,19.05 74.93,19.05 76.2,17.78 129.53,17.78 v132.08,15.24 | v146.05,20.32 148.59,20.32 IC40.2
DRV01\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v52.7,24.13 52.7,2.54 87.62,2.54 88.9,3.81 86.36,6.35 IC41.4
  Bottom 0.254: v52.7,24.13 42.54,24.13 41.27,25.4 RS08.38 | RF08A.38 284.48,57.78 285.11,57.15 288.29,57.15 288.92,56.52 J1.1 | RF08B.38 285.11,124.46 286.38,123.19 288.29,123.19 288.92,122.56 J15.1
DRV23\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v93.98,2.54 93.98,6.35 IC41.7 | v53.97,5.71 53.97,44.45 v54.6,45.09
  Bottom 0.254: v93.98,2.54 57.14,2.54 v53.97,5.71 | v54.6,45.09 53.97,44.45 42.54,44.45 41.27,45.72 RS08.22 | J1.3 288.92,48.9 283.84,53.98 266.69,53.98 265.43,55.24 265.43,57.78 264.16,57.78 RF08A.22 | RF08B.22 264.16,123.83 262.88,122.56 262.88,109.86 277.49,109.86 281.3,113.67 288.92,113.67 J15.3
DRVOK\  (via drill 0.61)  (2 unrouted)
  Top 0.254: IC21.13 80.64,103.5 79.37,103.5 IC21.14 78.73,102.87 80.01,101.6 v80.01,84.45 | v59.05,83.19 59.05,43.81 55.88,40.64 v55.88,22.86
  Bottom 0.254: 43.81,19.05 40.63,22.23 RS08.40 | 43.81,19.05 45.08,17.78 R2.1 | v80.01,84.45 78.73,83.19 v59.05,83.19 | v55.88,22.86 52.06,19.05 43.81,19.05 | D4.A 290.82,58.42 287.65,58.42 RF08A.40 | D8.A 290.82,124.46 287.65,124.46 RF08B.40
DRVSEL\  (1 unrouted)
  Top 0.254: IC42.22 264.16,44.45 263.52,43.81 263.52,32.38 262.88,31.75 262.88,24.13 264.16,22.86 IC43.22 | IC39.22 264.16,110.49 263.52,109.86 263.52,98.42 262.88,97.79 262.88,89.53 264.16,88.27 264.16,87.63 IC45.22
  Bottom 0.254: R3.1 236.85,15.24 262.88,15.24 263.52,15.88 263.52,19.05 264.16,19.68 264.16,20.32 IC43.22 264.79,22.23 269.87,27.3 287.65,27.3 | 287.65,27.3 288.92,26.04 IC44.4 | 287.65,27.3 301.62,27.3 301.62,57.78 D4.C | R4.1 236.85,78.74 242.56,84.45 262.25,84.45 263.52,85.72 IC45.22 264.79,87 271.14,93.34 287.65,93.34 288.92,92.08 IC46.4 | D8.C 300.99,124.46 292.73,116.2 268.6,116.2 264.79,112.39 IC39.22
EIE  (via drill 0.61)
  Top 0.254: 199.38,8.89 200.02,9.53 INTENB.6 200.66,8.89 200.66,5.71 207,5.71 208.28,6.99 208.28,25.4 210.18,27.3 IC37.2 | 199.38,8.89 v197.48,6.99 | v5.08,100.33 5.08,8.89 13.33,8.89 14.6,7.62 SV1.3 | v74.93,94.61 v74.93,106.05 | v136.52,87.63 139.06,85.09 139.06,74.93 138.43,74.3 v138.43,71.75 | v196.21,69.85 196.84,69.22 196.84,46.99 195.58,45.72 195.58,22.86 199.38,19.05 199.38,8.89
  Bottom 0.254: v197.48,6.99 187.32,6.99 185.41,8.89 160.02,8.89 158.75,10.16 IC40.9 | v5.08,100.33 10.79,106.05 v74.93,106.05 | v74.93,94.61 79.37,90.17 109.22,90.17 110.48,91.44 125.09,91.44 128.27,88.27 132.71,88.27 133.34,87.63 v136.52,87.63 | v138.43,71.75 139.06,71.12 177.8,71.12 178.43,71.75 180.34,71.75 182.24,69.85 v196.21,69.85
ERROR  (via drill 0.61)
  Top 0.254: v170.18,96.52 167.63,93.98 167.63,54.61 168.27,53.98 168.27,53.34 167.63,52.7 167.63,48.9 168.91,47.62 168.91,40.01 169.54,39.37 169.54,35.56 170.18,34.92 170.18,29.21 163.83,29.21 163.19,28.57 163.19,18.41 158.11,13.34 IC40.10 | v180.34,119.38 180.97,118.75 180.97,97.16 181.61,96.52 v181.61,94.61
  Bottom 0.254: v170.18,96.52 171.44,97.79 173.99,97.79 175.89,95.89 179.7,95.89 180.97,94.61 v181.61,94.61 211.45,94.61 212.72,95.89 212.72,98.42 211.45,98.42 IC12.6 | v180.34,119.38 184.78,123.83 IC7.2
EXAD0\  (via drill 0.61)
  Top 0.254: v12.06,88.27 11.42,87.63 11.42,74.3 13.96,71.75 13.96,65.41 12.69,64.14 C35L.34
  Bottom 0.254: v12.06,88.27 17.14,93.34 29.84,93.34 32.38,95.89 IC20.9
EXAD1\  (via drill 0.61)
  Top 0.254: v9.52,89.53 10.15,88.9 10.15,69.22 12.69,66.67 C35L.36
  Bottom 0.254: v9.52,89.53 13.96,93.98 25.39,93.98 27.3,95.89 IC20.7
EXAD2\  (via drill 0.61)
  Top 0.254: v10.79,94.61 10.79,71.12 12.69,69.22 C35L.38
  Bottom 0.254: v10.79,94.61 20.95,94.61 22.22,95.89 IC20.5
F.1  (via drill 0.61)
  Top 0.254: SV2.6 38.09,84.45 36.82,85.72 36.82,101.6 35.55,102.87 IC20.11 35.55,105.41 v35.55,139.06 | IC30.8 210.18,43.81 208.91,45.09 208.91,81.92 210.18,83.19 FIELD.3 210.18,84.45 205.1,89.53 v205.1,130.18
  Bottom 0.254: v35.55,139.06 37.46,140.97 92.7,140.97 93.98,139.7 150.49,139.7 151.76,138.43 153.03,138.43 154.3,139.7 155.57,139.7 156.21,139.06 156.21,134.62 200.66,134.62 v205.1,130.18
F.2  (via drill 0.61)
  Top 0.254: SV2.4 40.63,84.45 41.9,85.72 41.9,99.69 v38.73,102.87 43.17,107.31 v43.17,111.12 | v215.26,41.27 214.62,41.91 v214.62,86.36 v214.62,107.95 | v110.48,107.95 111.76,109.22 113.03,109.22 113.03,102.23 115.56,99.69 119.38,99.69 119.38,108.58 v118.74,109.22
  Bottom 0.254: v38.73,102.87 38.09,102.23 32.38,102.23 31.11,103.5 IC20.13 | v215.26,41.27 217.8,38.73 IC30.11 | v214.62,86.36 212.09,86.36 FIELD.2 | v43.17,111.12 44.45,112.39 44.45,113.67 68.58,113.67 72.39,109.86 99.69,109.86 100.96,108.58 107.95,108.58 109.22,107.31 109.85,107.31 v110.48,107.95 | v118.74,109.22 120.01,110.49 128.27,110.49 128.9,109.86 177.16,109.86 179.06,107.95 v214.62,107.95
F.3  (via drill 0.61)
  Top 0.254: v41.27,101.6 44.45,98.42 44.45,95.25 | 44.45,95.25 44.45,85.72 43.17,84.45 SV2.2 | v220.34,77.47 220.34,57.15 217.16,57.15 216.53,56.52 216.53,45.09 217.8,43.81 IC30.13 217.8,42.55 215.9,40.64 215.9,24.77 v212.72,21.59 | v43.81,95.25 44.45,95.25 | v71.75,89.53 76.2,85.09 v76.2,76.83 | v106.68,69.85 107.95,68.58 v107.95,28.57
  Bottom 0.254: v41.27,101.6 27.94,101.6 26.03,103.5 IC20.15 | v220.34,77.47 213.36,77.47 212.09,76.2 FIELD.6 | v43.81,95.25 44.45,94.61 66.67,94.61 v71.75,89.53 | v76.2,76.83 83.18,69.85 v106.68,69.85 | v107.95,28.57 111.12,25.4 122.55,25.4 123.82,24.13 168.91,24.13 171.44,21.59 v212.72,21.59
GND  (2 unrouted)
  Top 0.254: IC14.13 48.25,118.11 48.25,113.03 IC14.2 | IC20.17 20.32,105.41 20.32,110.49 IC13.2 19.68,111.12 18.41,111.12 IC13.1 | IC20.10 35.55,97.79 34.28,99.06 34.28,109.22 33.02,110.49 IC13.7 | IC14.1 45.08,112.39 43.17,112.39 C14.2 | RS08.31 38.09,32.38 39.36,31.11 39.36,24.77 38.09,23.5 RS08.39 | C35L.1 15.23,23.5 15.23,24.77 C35L.3 15.23,26.04 15.23,27.3 C35L.5 15.23,28.57 15.23,29.84 C35L.7 15.23,31.11 15.23,32.38 C35L.9 15.23,33.66 15.23,34.92 C35L.11 15.23,36.2 15.23,37.47 C35L.13 15.23,38.73 15.23,40.01 C35L.15 15.23,41.27 15.23,42.55 C35L.17 15.23,43.81 15.23,45.09 C35L.19 15.23,46.35 15.23,47.62 C35L.21 15.23,48.9 15.23,50.16 C35L.23 15.23,51.44 15.23,52.7 C35L.25 15.23,53.98 15.23,55.24 C35L.27 15.23,56.52 15.23,57.78 C35L.29 15.23,59.05 15.23,60.33 C35L.31 15.23,61.59 15.23,62.87 C35L.33 15.23,64.14 15.23,65.41 C35L.35 15.23,66.67 15.23,67.94 C35L.37 15.23,69.22 15.23,70.48 C35L.39 15.23,71.75 15.23,80.64 12.69,83.19 SV2.26 12.69,84.45 12.69,85.72 SV2.25 13.33,86.36 13.33,93.34 11.42,95.25 11.42,95.89 10.15,97.16 C20.2 10.15,98.42 13.96,102.23 13.96,111.12 15.23,112.39 C13.2 | 150.49,62.23 150.49,75.56 DAR8-11.8 149.22,76.83 147.95,78.11 147.95,84.45 | 150.49,62.23 C42.2 150.49,62.23 | 147.95,84.45 149.22,85.72 DAR8-11.4 | 147.95,84.45 147.95,96.52 150.49,96.52 C27.2 151.12,97.16 152.4,98.42 152.4,109.86 154.94,112.39 C18.2 | IC31.10 165.09,41.27 165.09,34.92 166.37,33.66 C38.2 | C40.2 151.12,26.04 151.12,40.64 150.49,41.27 DAR4-7.8 149.22,42.55 147.95,43.81 147.95,50.16 | 147.95,50.16 149.22,51.44 DAR4-7.4 | 150.49,62.23 147.95,62.23 147.95,50.16
  Top 0.254: D35L.39 86.36,70.48 86.36,69.22 D35L.37 86.36,67.94 86.36,66.67 D35L.35 86.36,65.41 86.36,64.14 D35L.33 86.36,62.87 86.36,61.59 D35L.31 86.36,60.33 86.36,59.05 D35L.29 86.36,57.78 86.36,56.52 D35L.27 86.36,55.24 86.36,53.98 D35L.25 86.36,52.7 86.36,51.44 D35L.23 86.36,50.16 86.36,48.9 D35L.21 86.36,47.62 86.36,46.35 D35L.19 86.36,45.09 86.36,43.81 D35L.17 86.36,42.55 86.36,41.27 D35L.15 86.36,40.01 86.36,38.73 D35L.13 86.36,37.47 86.36,36.2 D35L.11 86.36,34.92 86.36,33.66 D35L.9 86.36,32.38 86.36,31.11 D35L.7 86.36,29.84 86.36,28.57 D35L.5 86.36,27.3 86.36,26.04 D35L.3 86.36,24.77 86.36,23.5 D35L.1 | IC28.10 66.04,50.16 66.04,45.09 67.31,43.81 C35.2 67.31,42.55 67.94,41.91 67.94,32.38 67.31,31.75 71.75,27.3 | 71.75,26.04 71.75,24.77 73.02,23.5 IC35.13 | 71.75,26.04 73.02,27.3 IC35.15 | 71.75,27.3 71.75,26.04 | 71.75,27.3 71.75,31.11 73.02,32.38 IC35.17 | IC35.10 66.67,17.14 73.02,10.79 73.02,9.53 74.29,8.26 75.56,8.26 75.56,8.89 C41.2 | C39.2 135.88,62.87 135.88,74.93 135.25,75.56 DMA8-11.8 133.98,76.83 132.71,78.11 132.71,84.45 133.98,85.72 DMA8-11.4 | D36L.39 127,70.48 127,69.22 D36L.37 127,67.94 127,66.67 D36L.35 127,65.41 127,64.14 D36L.33 127,62.87 127,61.59 D36L.31 127,60.33 127,59.05 D36L.29 127,57.78 127,56.52 D36L.27 127,55.24 127,53.98 D36L.25 127,52.7 127,51.44 D36L.23 127,50.16 127,48.9 D36L.21 127,47.62 127,46.35 D36L.19 127,45.09 127,43.81 D36L.17 127,42.55 127,41.27 D36L.15 127,40.01 127,38.73 D36L.13 127,37.47 127,36.2 D36L.11 127,34.92 127,33.66 D36L.9 127,32.38 127,31.11 D36L.7 127,29.84 127,28.57 D36L.5 127,27.3 127,26.04 D36L.3 127,24.77 127,23.5 D36L.1
  Top 0.254: DMA0-3.4 133.34,17.78 131.44,17.78 131.44,22.23 133.34,24.13 136.52,24.13 136.52,27.94 C46.2 | C23.2 104.14,9.53 102.87,10.79 102.87,20.32 104.14,21.59 IC36.4 104.14,24.13 105.41,25.4 105.41,40.64 106.68,41.91 IC32.5 | J14.2 193.03,23.5 193.03,24.77 J13.2 193.03,26.04 193.03,27.3 J12.2 193.03,28.57 193.03,29.84 J11.2 193.03,31.11 193.03,32.38 J10.2 193.03,33.66 193.03,34.92 J9.2 193.03,36.2 193.03,37.47 J8.2 | D34L.1 185.41,23.5 185.41,24.77 D34L.3 185.41,26.04 185.41,27.3 D34L.5 185.41,28.57 185.41,29.84 D34L.7 185.41,31.11 185.41,32.38 D34L.9 185.41,33.66 185.41,34.92 D34L.11 185.41,36.2 185.41,37.47 D34L.13 185.41,38.73 185.41,40.01 D34L.15 185.41,41.27 185.41,42.55 D34L.17 185.41,43.81 185.41,45.09 D34L.19 185.41,46.35 185.41,47.62 D34L.21 185.41,48.9 185.41,50.16 D34L.23 185.41,51.44 185.41,52.7 D34L.25 185.41,53.98 185.41,55.24 D34L.27 185.41,56.52 185.41,57.78 D34L.29 185.41,59.05 185.41,60.33 D34L.31 185.41,61.59 185.41,62.87 D34L.33 185.41,64.14 185.41,65.41 D34L.35 185.41,66.67 185.41,67.94 D34L.37 185.41,69.22 185.41,70.48 D34L.39 | INTENB.4 196.21,9.53 197.48,9.53 INTENB.5 | 170.81,7.62 171.44,7.62 IC38.11 | 170.81,7.62 166.37,7.62 IC38.10 | 170.81,10.79 172.08,12.06 IC38.13 | 170.81,10.79 170.81,7.62 | 170.81,15.88 172.08,17.14 IC38.15 | 170.81,10.79 170.81,15.88 | 170.81,15.88 170.81,20.95 172.08,22.23 IC38.17 | INTENB.8 205.74,11.43 205.74,16.51 INTENB.9 205.74,19.05 203.19,21.59 203.19,22.23 C36L.1 203.19,23.5 203.19,24.77 C36L.3 203.19,26.04 203.19,27.3 C36L.5 203.19,28.57 203.19,29.84 C36L.7 203.19,31.11 203.19,32.38 C36L.9 203.19,33.66 203.19,34.92 C36L.11 203.19,36.2 203.19,37.47 C36L.13 203.19,38.73 203.19,40.01 C36L.15 203.19,41.27 203.19,42.55 C36L.17 203.19,43.81 203.19,45.09 C36L.19 203.19,46.35 203.19,47.62 C36L.21 203.19,48.9 203.19,50.16 C36L.23 203.19,51.44 203.19,52.7 C36L.25 203.19,53.98 203.19,55.24 C36L.27 203.19,56.52 203.19,57.78 C36L.29 203.19,59.05 203.19,60.33 C36L.31 203.19,61.59 203.19,62.87 C36L.33 203.19,64.14 203.19,65.41 C36L.35 203.19,66.67 203.19,67.94 C36L.37 203.19,69.22 203.19,70.48 C36L.39
  Top 0.254: IC37.10 210.18,8.26 208.91,9.53 208.91,15.88 210.18,17.14 IC37.6 | FIELD.8 211.45,70.48 211.45,64.77 212.09,64.14 C30.2 212.72,63.5 212.72,76.83 211.45,78.11 FIELD.5 210.18,79.38 210.18,80.64 FIELD.4 211.45,81.92 212.72,83.19 212.72,91.44 C44.2 212.09,92.08 212.09,95.25 211.45,95.89 IC12.7 211.45,97.16 212.72,98.42 212.72,114.3 C12.2 | C44X.2 212.09,133.99 211.45,133.35 211.45,132.72 IC8.1 | C31.2 166.37,67.94 165.73,68.58 165.73,75.56 IC24.10 165.73,76.83 167,78.11 167,99.69 166.37,100.33 166.37,100.97 C24.2 167,101.6 172.72,107.31 172.72,110.49 IC18.7 | IC7.8 200.66,123.19 199.38,121.92 199.38,114.3 200.66,113.03 IC11.7 | 132.08,121.92 132.08,120.65 IC17.15 132.08,118.11 129.53,115.57 129.53,113.03 IC17.1 | 132.08,121.92 132.08,123.19 IC9.2 132.08,125.73 134.62,128.27 134.62,130.81 IC9.12 | IC1.7 28.57,136.53 29.84,136.53 IC1.8 | C45.- 183.51,138.43 183.51,135.25 185.41,133.35 IC7.15 185.41,130.81 185.41,128.27 182.88,125.73 IC7.1 | IC10.12 162.56,130.81 162.56,128.27 160.02,125.73 IC10.2 | IC4.7 112.39,136.53 113.66,136.53 IC4.8 | IC5.7 144.78,135.89 144.78,134.62 143.5,133.35 143.5,127 144.78,125.73 IC9.7 144.14,123.83 144.14,121.92 132.08,121.92 | 312.42,25.4 312.42,43.81 G1.- 311.78,45.09 311.78,51.44 292.1,51.44 287.65,55.88 RF08A.39 | 312.42,25.4 312.42,14.61 G2.- | RF08A.31 277.49,55.88 277.49,48.26 278.12,47.62 278.12,46.99 278.12,44.45 277.49,43.81 277.49,41.91 276.22,40.64 276.22,31.11 IC42.16 276.86,29.21 275.58,27.94 275.58,8.89 276.86,7.62 IC43.16 | 312.42,25.4 297.81,25.4 IC44.7 | G3.- 313.05,109.86 314.32,109.86 G3.-@1
  Top 0.254: G4.- 313.05,79.38 314.32,79.38 G4.-@1 | RF08B.31 276.86,121.28 278.12,120.02 278.12,110.49 276.86,109.22 276.86,97.79 IC39.16
  Bottom 0.254: IC14.1 46.35,111.12 47.62,111.12 IC14.2 48.89,111.12 50.16,109.86 51.43,109.86 | 51.43,109.86 52.7,111.12 IC14.4 | 51.43,109.86 59.05,109.86 60.32,111.12 IC14.7 | C13.2 15.87,113.03 16.51,112.39 17.14,112.39 IC13.1 | IC20.10 36.19,97.16 36.82,97.79 42.54,97.79 C33.2 43.17,98.42 61.59,98.42 62.86,97.16 IC33.8 64.13,97.16 64.77,97.79 70.48,97.79 C21.2 71.75,97.79 72.39,97.79 73.02,98.42 89.53,98.42 90.8,97.16 IC21.8 92.07,97.16 92.7,97.79 98.42,97.79 C22.2 99.06,98.42 114.93,98.42 116.2,97.16 IC22.7 117.47,96.52 135.25,96.52 C8.2 136.52,96.52 137.79,97.79 149.22,97.79 150.49,96.52 C27.2 | C14.2 42.54,113.03 34.28,113.03 33.65,112.39 IC13.7 32.38,111.12 31.11,109.86 22.22,109.86 20.95,111.12 IC13.2 | RS08.39 37.46,22.86 33.65,19.05 29.21,19.05 28.57,18.41 24.76,18.41 24.12,17.78 IC34.10 21.59,17.78 20.95,18.41 15.23,18.41 11.42,22.23 11.42,24.13 13.33,24.13 14.6,25.4 C35L.3 | C34.2 23.49,43.18 15.87,43.18 C35L.17 | C26.2 23.49,76.2 19.68,76.2 15.23,71.75 C35L.39 | IC26.10 21.59,50.8 15.87,50.8 C35L.23 | J2.2 10.79,50.8 12.06,52.07 13.33,52.07 14.6,53.34 C35L.25 | IC31.10 163.83,41.91 160.65,41.91 159.38,43.18 152.4,43.18 151.12,41.91 DAR4-7.8 148.59,41.91 147.31,43.18 132.08,43.18 | D35L.31 86.99,60.96 92.07,60.96 93.34,59.69 C29.2 93.98,60.33 104.77,60.33 106.04,59.05 IC29.5 107.31,57.78 108.58,56.52 112.39,56.52 113.66,57.78 IC29.8 | C28.2 67.94,76.2 69.84,78.11 78.73,78.11 85.72,71.12 D35L.39 86.99,71.12 89.53,71.12 93.34,74.93 C25.2 93.98,75.56 104.77,75.56 | 104.77,75.56 106.04,74.3 IC25.5 | 104.77,75.56 112.39,75.56 113.66,74.3 IC25.8
  Bottom 0.254: C36.2 93.34,24.13 92.07,25.4 86.99,25.4 D35L.3 | D35L.17 86.99,43.18 92.07,43.18 93.34,44.45 C32.2 93.98,45.09 104.77,45.09 | 104.77,45.09 106.04,43.81 IC32.5 | 104.77,45.09 112.39,45.09 113.66,43.81 IC32.8 | IC35.17 74.93,33.02 76.2,31.75 84.45,31.75 85.72,30.48 D35L.7 | IC40.7 148.59,7.62 147.31,8.89 137.16,8.89 135.88,7.62 DMA0-3.8 133.34,7.62 122.55,7.62 IC23.7 121.28,6.99 120.01,5.71 111.12,5.71 109.85,6.99 IC23.2 108.58,8.26 107.31,9.53 104.14,9.53 C23.2 103.5,8.89 97.79,8.89 97.15,8.26 IC41.8 95.88,8.26 94.61,9.53 76.2,9.53 C41.2 | C39.2 135.25,62.23 133.98,63.5 127.63,63.5 D36L.33 | 132.08,43.18 133.34,41.91 DMA4-7.8 | 132.08,43.18 127.63,43.18 D36L.17 | DMA4-7.4 133.34,52.07 129.53,48.26 127.63,48.26 D36L.21 | IC36.4 104.77,22.23 106.04,22.23 IC36.5 107.31,23.5 108.58,24.77 112.39,24.77 113.66,23.5 IC36.8 114.93,22.23 115.56,21.59 125.09,21.59 126.36,22.86 D36L.1 | C46.2 135.25,27.94 127.63,27.94 D36L.5 | J6.2 192.4,43.18 186.05,43.18 D34L.17 | J8.2 192.4,38.1 186.05,38.1 D34L.13 | IC38.13 173.35,12.06 184.15,12.06 184.78,11.43 C43.2 185.41,12.06 193.67,12.06 194.94,10.79 INTENB.4 | IC19.7 201.29,89.53 203.19,91.44 211.45,91.44 C44.2 | C19.2 191.13,99.06 191.77,98.42 207.64,98.42 209.55,96.52 IC12.7 | INTENB.9 206.37,17.78 209.55,17.78 IC37.6 | C37.2 211.45,33.02 203.83,33.02 C36L.9 202.56,33.02 201.29,31.75 194.94,31.75 193.67,33.02 J10.2 | IC30.10 209.55,38.1 203.83,38.1 C36L.13 | FIELD.9 217.16,71.12 212.09,71.12 FIELD.8 209.55,71.12 203.83,71.12 C36L.39 | IC30.6 209.55,48.26 203.83,48.26 C36L.21 | INTENB.5 198.75,10.79 200.02,12.06 203.83,12.06 205.1,10.79 INTENB.8
  Bottom 0.254: IC7.8 201.29,125.09 208.28,132.08 209.55,132.08 IC8.1 | C12.2 211.45,114.3 203.19,114.3 201.29,112.39 IC11.7 200.02,112.39 198.75,113.67 182.88,113.67 C11.2 182.24,113.03 181.61,112.39 173.35,112.39 IC18.7 172.08,112.39 170.81,113.67 154.94,113.67 C18.2 154.3,113.03 148.59,113.03 147.95,112.39 IC17.8 146.68,112.39 145.41,113.67 127,113.67 C17.2 | IC16.15 102.23,118.75 104.14,116.84 129.53,116.84 131.44,118.75 IC17.15 | C9.2 127.63,125.73 128.27,126.36 130.17,126.36 131.44,125.09 IC9.2 | C15.2 71.12,113.67 79.37,113.67 80.64,112.39 IC15.4 81.91,112.39 83.18,113.67 86.99,113.67 88.26,112.39 IC15.7 89.53,112.39 90.17,113.03 95.88,113.03 C16.2 97.15,113.03 97.79,113.03 98.42,112.39 IC16.1 99.69,111.12 100.96,109.86 114.93,109.86 116.2,111.12 IC16.8 117.47,112.39 118.11,113.03 126.36,113.03 C17.2 | IC17.1 128.9,112.39 128.27,113.03 127.63,113.03 C17.2 | C1.2 10.79,138.43 11.42,139.06 26.03,139.06 27.3,137.79 IC1.7 | IC1.8 31.11,137.79 36.82,137.79 37.46,138.43 C2.2 38.09,139.06 53.97,139.06 55.24,137.79 IC2.7 56.51,136.53 57.78,136.53 IC2.8 59.05,137.79 64.77,137.79 65.4,138.43 C3.2 66.04,139.06 81.91,139.06 83.18,137.79 IC3.7 84.45,136.53 85.72,136.53 IC3.8 86.99,137.79 92.7,137.79 93.34,138.43 C4.2 94.61,138.43 95.25,139.06 109.85,139.06 111.12,137.79 IC4.7 | IC7.1 182.24,125.09 181.61,125.73 180.97,125.73 C7.2 179.7,125.73 173.99,125.73 173.35,125.09 IC10.7 172.08,125.09 170.81,126.36 158.11,126.36 | IC6.8 175.89,137.79 177.16,139.06 181.61,139.06 C45.- | IC9.7 145.41,125.09 146.05,125.73 154.3,125.73 C10.2 154.94,126.36 158.11,126.36
  Bottom 0.254: 158.11,126.36 159.38,125.09 IC10.2 | C6.2 154.94,137.79 145.41,137.79 IC5.7 144.14,137.79 142.87,139.06 127,139.06 C5.2 126.36,138.43 125.73,137.79 114.93,137.79 IC4.8 | G2.- 313.05,13.97 314.32,13.97 G2.-@1 | G1.- 313.05,44.45 314.32,44.45 G1.-@1 | RF08A.31 277.49,55.88 278.76,54.61 285.11,54.61 286.38,55.88 RF08A.39 | RF08B.31 277.49,121.92 278.76,123.19 285.11,123.19 286.38,121.92 RF08B.39 | IC45.16 277.49,71.75 296.54,90.81 IC46.7 | 295.27,93.34 296.54,92.08 IC46.7 | 295.27,93.34 294.63,93.98 279.39,93.98 277.49,95.89 IC39.16 | G4.- 311.78,80.64 301.62,90.81 297.81,90.81 IC46.7 | 295.27,93.34 311.78,109.86 G3.-
INT_RQ\  (via drill 0.61)
  Top 0.254: IC40.3 149.22,17.14 147.95,15.88 147.95,12.06 149.22,10.79 IC40.6 | v154.3,58.42 154.94,57.78 154.94,50.16 155.57,49.53 155.57,33.02 154.3,31.75 154.3,10.79 156.84,8.26 IC40.8
  Bottom 0.254: IC40.6 151.12,10.16 153.66,7.62 156.21,7.62 IC40.8 | v154.3,58.42 158.75,58.42 160.02,59.69 160.65,59.69 161.92,58.42 182.24,58.42 D34L.30
IOS\  (via drill 0.61)
  Top 0.254: v119.38,97.79 119.38,98.42 115.56,98.42 112.39,101.6 112.39,102.23 111.76,102.87 IC22.10 | v139.06,99.69 142.87,103.5 v142.87,106.05 | v153.66,107.31 154.94,106.05 v154.94,95.25 | v182.24,90.17 182.24,87.63 181.61,87 181.61,57.78 182.88,56.52 D34L.28
  Bottom 0.254: v119.38,97.79 135.25,97.79 137.16,99.69 v139.06,99.69 | v142.87,106.05 144.14,107.31 v153.66,107.31 | v154.94,95.25 177.16,95.25 v182.24,90.17
MEMSUPPLY  (via drill 0.61)  (1 unrouted)
  Top 0.508: v236.22,21.59 236.22,24.77 R3.2 236.22,26.04 236.22,44.45 D1.C | D3.C 278.76,13.34 278.76,42.55 D2.C | D6.C 236.22,110.49 236.22,89.53 R4.2 | D7.C 278.76,79.38 278.76,108.58 D5.C
  Bottom 0.508: D1.C 236.85,45.72 238.12,45.72 IC42.32 238.75,44.45 240.03,43.18 278.12,43.18 D2.C 280.03,42.55 281.94,42.55 281.94,34.29 IC44.14 | v236.22,21.59 238.12,21.59 IC43.32 | D6.C 236.85,111.12 238.12,111.12 IC39.32 239.39,111.12 241.3,109.22 278.12,109.22 D5.C 280.03,108.58 281.94,108.58 281.94,100.33 IC46.14 | R4.2 236.22,88.27 237.49,87 238.12,87 IC45.32
MYDEV\  (via drill 0.61)
  Top 0.254: 102.87,55.88 102.87,45.72 104.14,44.45 IC32.4 104.14,41.91 v104.14,38.1 | 102.87,55.88 104.14,57.15 IC29.4 | 102.87,55.88 102.87,71.12 104.14,72.39 IC25.4
  Bottom 0.254: v104.14,38.1 111.12,38.1 113.66,35.56 PAD1.1
N$1
  Top 0.254: IC36.9 114.3,31.75 114.3,32.38 PAD8.1
N$2  (via drill 0.61)
  Top 0.254: v194.31,130.18 194.31,121.92 193.03,120.65 IC11.11
  Bottom 0.254: v194.31,130.18 184.78,130.18 184.15,130.81 182.88,129.54 175.25,129.54 173.35,131.44 IC10.8
N$3  (via drill 0.61)
  Top 0.254: v145.41,49.53 144.78,48.9 144.78,11.43 140.97,11.43 140.33,12.06 140.33,15.24 135.88,15.24 DMA0-3.5
  Bottom 0.254: v145.41,49.53 143.5,49.53 DMA4-7.12
N$4  (via drill 0.61)
  Top 0.254: SW1.1 13.33,123.83 14.6,123.83 SW1.2 | SW1.3 18.41,123.83 19.68,123.83 SW1.4 20.95,123.83 22.22,123.83 SW1.5 23.49,123.83 24.76,123.83 SW1.6 26.03,123.83 27.3,123.83 SW1.7 | v53.34,93.34 53.34,95.25 IC33.4 | v40.63,93.98 37.46,97.16 v37.46,123.19
  Bottom 0.254: SW1.3 17.14,123.83 15.87,123.83 SW1.2 | SW1.7 28.57,123.83 29.84,123.83 SW1.8 31.11,123.83 36.82,123.83 v37.46,123.19 | v53.34,93.34 52.7,93.98 v40.63,93.98
N$5
  Top 0.254: IC36.15 99.06,31.75 99.06,32.38 PAD2.1
N$6
  Top 0.254: IC36.14 101.59,31.75 101.59,32.38 PAD3.1
N$7
  Top 0.254: IC36.13 104.14,31.75 104.14,32.38 PAD4.1
N$8
  Top 0.254: IC36.12 106.68,31.75 106.68,32.38 PAD5.1
N$9
  Top 0.254: IC36.11 109.22,31.75 109.22,32.38 PAD6.1
N$10
  Top 0.254: IC36.10 111.76,31.75 111.76,32.38 PAD7.1
N$11
  Top 0.254: IC36.7 111.76,24.13 116.84,29.21 116.84,32.38 PAD9.1
N$12
  Top 0.254: DAR4-7.14 156.84,55.24 155.57,56.52 155.57,60.33 156.21,60.96 157.47,60.96 157.47,73.66 155.57,75.56 155.57,87 156.84,88.27 DAR8-11.14 158.11,89.53 159.38,90.81 159.38,97.79 161.28,99.69 161.28,113.67 167,113.67 172.08,118.75 IC18.8
N$13  (via drill 0.61)
  Top 0.254: v145.41,50.8 144.78,51.44 144.78,81.28 142.87,83.19 DMA8-11.12
  Bottom 0.254: v145.41,50.8 137.16,50.8 135.88,49.53 DMA4-7.5
N$14  (via drill 0.61)
  Top 0.254: IC13.8 33.02,120.65 34.28,121.92 34.28,141.6 42.54,149.86 54.6,149.86 54.6,143.51 60.95,137.16 60.95,120.65 IC14.8 | v87.62,117.47 87.62,114.3 86.36,113.03 IC15.6
  Bottom 0.254: v87.62,117.47 87.62,121.28 62.86,121.28 61.59,120.02 IC14.8
N$15  (via drill 0.61)
  Top 0.254: v49.52,147.96 49.52,139.7 50.79,138.43 IC2.5 | v125.09,149.22 128.27,146.05 128.27,142.24 132.08,138.43 IC5.2
  Bottom 0.254: v49.52,147.96 51.43,149.86 124.45,149.86 v125.09,149.22
N$16  (via drill 0.61)
  Top 0.254: v146.68,15.24 147.31,15.88 v147.31,72.39 | v151.76,74.93 151.76,81.92 150.49,83.19 DAR8-11.5
  Bottom 0.254: v146.68,15.24 143.5,15.24 DMA0-3.12 | v147.31,72.39 149.86,74.93 v151.76,74.93
N$17
  Top 0.254: SW2.1 41.27,123.83 42.54,123.83 SW2.2 43.81,123.83 45.08,123.83 SW2.3 46.35,123.83 47.62,123.83 SW2.4 48.89,123.83 50.16,123.83 SW2.5 51.43,123.83 52.7,123.83 SW2.6 | IC33.5 55.88,97.79 54.6,99.06 54.6,121.92 53.34,123.19 SW2.6 | SW2.6 53.97,123.83 55.24,123.83 SW2.7 56.51,123.83 57.78,123.83 SW2.8
N$18
  Top 0.254: IC44.6 294,24.77 292.73,24.77 IC44.5
  Bottom 0.254: IC44.5 292.1,24.13 291.46,23.5 287.65,23.5 287.01,24.13 IC44.3
N$19  (via drill 0.61)
  Top 0.254: v58.41,99.69 58.41,97.79 IC33.6 | v67.31,99.06 67.94,99.69 67.94,123.83 SW3.1 | SW3.2 71.75,123.83 73.02,123.83 SW3.3 74.29,123.83 75.56,123.83 SW3.4 76.83,123.83 78.1,123.83 SW3.5 79.37,123.83 80.64,123.83 SW3.6 81.91,123.83 83.18,123.83 SW3.7 84.45,123.83 85.72,123.83 SW3.8
  Bottom 0.254: v58.41,99.69 59.05,99.06 v67.31,99.06 | SW3.2 70.48,123.83 69.21,123.83 SW3.1
N$20  (via drill 0.61)
  Top 0.254: v60.95,100.33 60.95,97.79 IC33.7 | v92.7,100.97 v92.7,123.19 | SW4.1 97.15,123.83 98.42,123.83 SW4.2 99.69,123.83 100.96,123.83 SW4.3 102.23,123.83 103.5,123.83 SW4.4 104.77,123.83 106.04,123.83 SW4.5 | SW4.6 109.85,123.83 111.12,123.83 SW4.7 112.39,123.83 113.66,123.83 SW4.8
  Bottom 0.254: v60.95,100.33 72.39,100.33 73.02,99.69 88.9,99.69 90.17,100.97 v92.7,100.97 | v92.7,123.19 93.34,123.83 95.88,123.83 SW4.1 | SW4.6 108.58,123.83 107.31,123.83 SW4.5
N$21  (via drill 0.61)
  Top 0.254: v77.47,147.96 77.47,143.51 78.1,142.88 78.1,139.06 78.73,138.43 IC3.5 | v127.63,147.96 135.88,147.96 135.88,139.7 137.16,138.43 IC5.4
  Bottom 0.254: v77.47,147.96 98.42,147.96 99.69,149.22 123.82,149.22 125.09,147.96 v127.63,147.96
N$22  (via drill 0.61)
  Top 0.254: 140.33,52.7 140.33,41.27 142.24,39.37 142.24,26.67 140.97,26.67 140.33,26.04 140.33,22.23 141.6,20.95 DMA0-3.14 | 140.33,52.7 141.6,53.98 DMA4-7.14 | 140.33,52.7 140.33,60.96 141.6,60.96 142.24,61.59 142.24,73.03 140.33,74.93 140.33,87 141.6,88.27 DMA8-11.14 142.87,89.53 144.14,90.81 v144.14,106.05 | v170.18,106.05 170.18,110.49 IC18.6
  Bottom 0.254: v170.18,106.05 v144.14,106.05
N$23
  Bottom 0.254: IC1.5 23.49,136.53 24.76,135.25 115.56,135.25 116.84,136.53 128.9,136.53 IC5.1
N$24
  Top 0.254: IC4.5 106.68,138.43 106.04,139.06 106.04,142.88 105.41,143.51 105.41,146.05 109.85,150.5 138.43,150.5 138.43,139.7 139.69,138.43 IC5.5
N$25  (via drill 0.61)
  Top 0.254: v154.3,49.53 153.66,50.16 153.66,57.78 153.03,58.42 153.03,75.56 152.4,76.2 v152.4,83.82
  Bottom 0.254: v154.3,49.53 151.12,49.53 DAR4-7.5 | v152.4,83.82 156.21,83.82 DAR8-11.12
N$26
  Top 0.254: IC22.1 101.59,97.79 102.87,99.06 102.87,113.03 107.31,117.47 111.12,117.47 111.12,118.75 IC16.11
N$27  (via drill 0.61)
  Top 0.254: v133.34,106.05 137.16,109.86 137.16,110.49 IC17.4
  Bottom 0.254: v133.34,106.05 111.12,106.05 109.85,104.78 IC22.11
N$28  (via drill 0.61)
  Top 0.254: v184.15,121.28 184.15,91.44 185.41,90.17 IC19.1
  Bottom 0.254: v184.15,121.28 185.41,122.56 191.13,122.56 192.4,123.83 IC7.5
N$29
  Top 0.254: RA.2 220.97,120.02 220.97,121.28 RB.1 220.97,122.56 222.25,123.83 222.25,125.73 219.07,128.91 IC8.7
N$30
  Top 0.254: IC12.2 210.18,109.86 210.18,111.12 IC12.1 210.81,112.39 210.81,117.47 212.72,119.38 212.72,125.09 211.45,126.36 IC8.3 209.55,127 208.28,128.27 208.28,128.91 RL.2
N$31
  Top 0.254: IC18.11 165.09,120.65 166.37,121.92 166.37,129.54 167.63,130.81 IC10.10
N$32
  Top 0.254: C44X.1 217.16,133.99 216.53,133.35 216.53,128.91 217.8,127.64 IC8.6
  Bottom 0.254: 215.26,125.73 216.53,127 217.16,127 IC8.6 | 215.26,125.73 211.45,121.92 RB.2 | 215.26,125.73 214.62,125.73 211.45,128.91 IC8.2
N$33
  Top 0.254: IC19.11 193.03,97.79 191.77,99.06 191.77,129.54 193.03,130.81 IC7.12
N$34
  Top 0.254: IC8.5 219.71,124.46 220.34,124.46 C43X.2
N$35
  Top 0.254: IC44.2 285.11,26.04 285.75,26.67 285.75,52.07 288.92,52.07 J1.2
  Bottom 0.254: IC44.2 283.84,24.77 282.57,24.77 IC44.1
N$36
  Top 0.254: D7.A 290.19,78.11 291.46,76.83 G4.+@1 | G4.+@2 294,75.56 292.73,75.56 G4.+@1 | G4.+@3 294,84.45 292.73,84.45 G4.+ 292.73,83.19 293.37,82.55 293.37,81.28 G4.+@4 293.37,78.74 293.37,77.47 292.73,76.83 G4.+@1
N$37
  Top 0.254: IC12.9 217.8,99.69 217.8,100.97 IC12.10 217.8,102.23 217.8,103.5 IC12.11
N$38
  Top 0.254: IC46.6 294,90.81 292.73,90.81 IC46.5
  Bottom 0.254: IC46.3 287.65,90.81 288.92,89.53 290.19,89.53 291.46,90.81 IC46.5
N$39
  Top 0.254: IC46.2 284.48,90.17 287.01,87.63 290.82,87.63 290.82,105.41 287.65,108.58 287.65,116.2 288.92,117.47 J15.2
  Bottom 0.254: IC46.1 282.57,90.81 283.84,90.81 IC46.2
N$40
  Bottom 0.254: IC12.5 212.09,101.6 217.16,96.52 IC12.8
N$41
  Top 0.254: D5.A 290.19,108.58 291.46,107.31 G3.+@1 | G3.+@2 294,106.05 292.73,106.05 G3.+@1 | G3.+@3 294,114.94 292.73,114.94 G3.+ 292.73,113.67 293.37,113.03 293.37,111.76 G3.+@4 293.37,109.22 293.37,107.95 292.73,107.31 G3.+@1
N$53
  Top 0.254: SW1.16 13.33,131.44 14.6,130.18 19.05,130.18 19.05,133.99 20.32,135.25 20.32,135.89 IC1.4
N$54
  Top 0.254: SW1.15 15.23,133.35 17.78,135.89 IC1.3
N$55
  Bottom 0.254: SW1.14 17.78,133.35 15.23,135.89 IC1.2
N$56
  Bottom 0.254: IC1.1 13.33,136.53 16.51,133.35 16.51,130.18 18.41,130.18 19.68,131.44 SW1.13
N$57  (via drill 0.61)
  Top 0.254: v19.05,135.25 19.05,140.97 17.78,142.24 17.78,143.51 IC1.14
  Bottom 0.254: v19.05,135.25 22.22,135.25 24.76,132.72 SW1.11
N$58
  Top 0.254: SW1.10 27.3,132.72 24.12,135.89 24.12,139.7 20.32,143.51 IC1.13
N$59
  Top 0.254: SW1.9 29.84,132.72 26.67,135.89 26.67,139.7 22.86,143.51 IC1.12
N$60
  Top 0.254: SW1.12 22.86,133.35 21.59,134.62 21.59,139.7 19.05,142.24 19.05,146.05 18.41,146.69 15.23,146.69 15.23,146.05 IC1.15
N$61
  Top 0.254: SW2.16 40.63,133.35 41.9,134.62 41.9,138.43 42.54,139.06 47.62,139.06 47.62,137.79 IC2.4
N$62
  Top 0.254: SW2.15 43.17,133.35 45.71,135.89 IC2.3
N$63
  Top 0.254: SW2.14 45.08,131.44 43.81,130.18 41.9,130.18 41.9,133.35 43.17,134.62 43.17,135.89 IC2.2
N$64
  Top 0.254: IC2.1 40.63,135.89 39.36,134.62 39.36,130.81 40.63,129.54 47.62,129.54 47.62,131.44 SW2.13
N$65
  Top 0.254: SW2.11 52.7,132.72 49.52,135.89 49.52,138.43 45.71,142.24 45.71,143.51 IC2.14
N$66
  Top 0.254: SW2.10 56.51,131.44 57.78,130.18 59.68,130.18 59.68,133.35 57.14,135.89 57.14,138.43 52.06,143.51 52.06,146.69 49.52,149.22 48.25,149.22 48.25,146.05 IC2.13
N$67
  Top 0.254: SW2.9 57.78,132.72 54.6,135.89 54.6,139.7 50.79,143.51 IC2.12
N$68
  Top 0.254: SW3.16 69.21,131.44 70.48,130.18 74.93,130.18 74.93,133.35 76.2,134.62 76.2,135.89 IC3.4
N$69
  Top 0.254: SW3.15 71.12,133.35 73.66,135.89 IC3.3
N$70
  Top 0.254: SW3.14 73.66,133.35 74.93,134.62 74.93,138.43 74.29,139.06 71.12,139.06 71.12,138.43 IC3.2
N$71
  Top 0.254: IC3.1 68.58,135.89 67.31,134.62 67.31,130.81 68.58,129.54 75.56,129.54 75.56,131.44 SW3.13
N$72
  Top 0.254: SW3.11 81.28,133.35 82.55,134.62 82.55,146.05 78.73,149.86 69.84,149.86 69.84,143.51 70.48,142.88 73.02,142.88 73.02,144.15 IC3.14
N$73
  Top 0.254: SW3.10 83.18,131.44 81.91,130.18 77.47,130.18 77.47,142.24 76.2,143.51 IC3.13
N$74  (via drill 0.61)
  Top 0.254: v87.62,142.24 87.62,134.62 86.36,133.35 SW3.9
  Bottom 0.254: v87.62,142.24 86.99,142.88 80.64,142.88 79.37,144.15 IC3.12
N$75
  Top 0.254: SW4.16 97.15,131.44 98.42,130.18 102.87,130.18 102.87,133.35 104.14,134.62 104.14,135.89 IC4.4
N$76
  Top 0.254: SW4.15 99.06,133.35 101.59,135.89 IC4.3
N$77
  Top 0.254: SW4.14 101.59,133.35 102.87,134.62 102.87,138.43 102.23,139.06 99.06,139.06 99.06,138.43 IC4.2
N$78
  Top 0.254: IC4.1 96.52,135.89 95.25,134.62 95.25,130.81 96.52,129.54 103.5,129.54 103.5,131.44 SW4.13
N$79  (via drill 0.61)
  Top 0.254: v97.79,133.99 97.79,139.7 101.59,143.51 IC4.14
  Bottom 0.254: v97.79,133.99 107.31,133.99 108.58,132.72 SW4.11
N$80
  Top 0.254: SW4.10 111.12,132.72 108.58,135.25 105.41,135.25 105.41,142.24 104.14,143.51 IC4.13
N$81
  Top 0.254: SW4.9 113.66,132.72 110.48,135.89 110.48,139.7 106.68,143.51 IC4.12
N$82
  Top 0.254: SW4.12 106.68,130.81 103.5,127.64 94.61,127.64 94.61,137.16 95.25,137.79 95.25,139.7 99.06,143.51 IC4.15
N$83
  Top 0.254: SW3.12 78.73,133.35 80.01,134.62 80.01,146.69 77.47,149.22 71.12,149.22 71.12,146.05 IC3.15
N$84
  Top 0.254: SW2.12 50.79,130.81 47.62,127.64 38.73,127.64 38.73,137.16 39.36,137.79 39.36,139.7 43.17,143.51 IC2.15
N$130
  Top 0.254: G2.+@1 292.1,10.79 292.1,17.14 G2.+ 292.73,18.41 292.73,19.05 294,19.05 G2.+@3 294.63,18.41 294.63,15.24 G2.+@4 | G2.+@4 294.63,12.7 294.63,9.53 G2.+@2 | D3.A 290.82,12.7 293.37,12.7 G2.+@4
N$131
  Top 0.254: G1.+@1 292.1,41.27 292.1,47.62 G1.+ 292.73,48.9 292.73,49.53 294,49.53 G1.+@3 294.63,48.9 294.63,45.72 G1.+@4 | G1.+@4 294.63,43.18 294.63,40.01 G1.+@2 | D2.A 290.82,43.18 293.37,43.18 G1.+@4
NXD  (via drill 0.61)
  Top 0.254: v207.64,53.34 207,52.7 v207,6.99 | v118.74,4.45 116.84,6.35 IC23.5
  Bottom 0.254: IC23.5 116.2,8.26 114.3,10.16 74.93,10.16 74.29,10.79 53.97,10.79 52.06,8.89 34.92,8.89 33.65,7.62 SV1.17 | v207.64,53.34 209.55,53.34 IC30.4 | v207,6.99 205.74,5.71 153.66,5.71 153.03,6.35 137.16,6.35 135.88,5.08 119.38,5.08 v118.74,4.45
NXD\  (via drill 0.61)
  Top 0.254: v134.62,71.75 134.62,65.41 130.17,60.96 130.17,52.7 129.53,52.07 129.53,39.37 130.17,38.73 130.17,24.13 127.63,21.59 127.63,5.08 121.92,5.08 120.01,6.99 IC23.6 | v146.05,73.03 147.31,74.3 147.31,109.22 148.59,110.49 148.59,135.89 150.49,137.79 150.49,140.34 v153.03,142.88
  Bottom 0.254: v134.62,71.75 135.88,73.03 v146.05,73.03 | v153.03,142.88 153.66,142.24 161.28,142.24 161.92,142.88 210.81,142.88 225.42,128.27 225.42,107.31 219.07,107.31 IC12.12
PBIT  (via drill 0.61)
  Top 0.254: v61.59,90.17 60.95,89.53 60.95,43.81 62.22,42.55 62.22,24.13 67.31,24.13 73.02,18.41 IC35.11 | v58.41,93.34 57.14,94.61 57.14,109.22 58.41,110.49 IC14.6
  Bottom 0.254: v61.59,90.17 v58.41,93.34
PCA
  Bottom 0.254: IC40.5 151.12,12.7 152.4,13.97 179.06,13.97 180.34,12.7 209.55,12.7 IC37.8 212.09,12.7 213.36,11.43 224.15,11.43 224.15,95.89 219.71,100.33 217.16,100.33 211.45,106.05 IC12.3
PER  (via drill 0.61)
  Top 0.254: v204.47,64.77 204.47,129.54 203.19,130.81 203.19,138.43 191.13,150.5 143.5,150.5 143.5,134.62 142.24,133.35 IC9.9 | v34.28,31.75 34.28,23.5 36.82,20.95 36.82,9.53 38.09,8.26 SV1.21 | v166.37,37.47 168.91,34.92 v168.91,33.66
  Bottom 0.254: v204.47,64.77 210.18,59.05 IC30.2 211.45,57.78 216.53,57.78 217.16,57.15 220.97,57.15 220.97,38.1 217.16,34.29 169.54,34.29 v168.91,33.66 | v34.28,31.75 36.82,34.29 127.63,34.29 129.53,36.2 149.86,36.2 151.12,37.47 v166.37,37.47
PER\  (via drill 0.61)
  Top 0.254: v146.05,102.87 146.05,129.54 144.78,130.81 IC9.8 | v157.47,102.87 160.02,105.41 v160.02,107.31
  Bottom 0.254: v157.47,102.87 v146.05,102.87 | v160.02,107.31 206.37,107.31 209.55,104.14 IC12.4
PIE  (via drill 0.61)