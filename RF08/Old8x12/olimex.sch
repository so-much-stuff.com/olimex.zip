# EAGLE board olimex (EAGLE 4.11), part 3 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
PIE  (via drill 0.61) (continued)
  Top 0.254: v186.05,4.45 190.5,8.89 INTENB.2 | v153.03,5.08 151.76,6.35 | 151.76,6.35 151.76,13.34 150.49,14.61 IC40.4 | v221.61,8.26 221.61,50.16 219.07,52.7 IC30.17 | 151.76,6.35 151.76,1.91 101.59,1.91 98.42,5.08 98.42,9.53 93.34,9.53 92.7,8.89 92.7,1.91 24.12,1.91 18.41,7.62 SV1.5
  Bottom 0.254: v153.03,5.08 185.41,5.08 v186.05,4.45 217.8,4.45 v221.61,8.26
PROTECT  (via drill 0.61)
  Top 0.254: v142.24,140.97 142.24,138.43 IC5.6 | v162.56,140.97 162.56,138.43 IC6.3
  Bottom 0.254: v142.24,140.97 v162.56,140.97
SETNXD\
  Top 0.254: IC23.4 113.66,6.99 112.39,5.71 99.06,5.71 99.06,17.14 91.44,24.77 91.44,43.18 92.07,43.81 92.07,94.61 92.7,95.25 92.7,99.69 91.44,100.97 91.44,102.87 IC21.9
SETPER\
  Bottom 0.254: IC13.5 27.3,112.39 25.39,114.3 22.86,114.3 19.05,118.11 19.05,122.56 12.06,122.56 11.42,123.19 11.42,129.54 137.16,129.54 139.06,131.44 IC9.10
SETWLS\  (via drill 0.61)
  Top 0.254: v139.69,128.27 137.16,125.73 IC9.4 | v171.44,130.18 171.44,134.62 172.72,135.89 IC6.7
  Bottom 0.254: v139.69,128.27 140.97,129.54 160.02,129.54 160.65,130.18 v171.44,130.18
SKIP\  (via drill 0.61)
  Top 0.254: IC19.6 198.12,90.17 195.58,92.71 195.58,95.25 IC19.10 195.58,97.79 v195.58,104.14 | v132.08,104.78 132.08,110.49 IC17.2
  Bottom 0.254: R1.1 183.51,86.36 184.15,87 186.05,87 187.32,88.27 IC19.2 188.59,88.27 189.86,87 196.21,87 197.48,88.27 IC19.6 | v132.08,104.78 144.14,104.78 144.78,105.41 169.54,105.41 170.81,104.14 v195.58,104.14
START\  (via drill 0.61)
  Top 0.254: 144.14,45.09 144.14,14.61 142.87,13.34 DMA0-3.11 | 144.14,45.09 142.87,46.35 DMA4-7.11 | 144.14,45.09 144.14,79.38 142.87,80.64 DMA8-11.11 | v162.56,100.33 162.56,110.49 IC18.3 | v146.05,99.69 v146.05,81.28
  Bottom 0.254: v162.56,100.33 149.86,100.33 148.59,99.06 146.68,99.06 v146.05,99.69 | v146.05,81.28 143.5,81.28 DMA8-11.11
VCC  (via drill 0.61)  (2 unrouted)
  Top 0.508: J7.2 193.03,41.27 191.13,43.18 191.13,45.72 193.03,47.62 J5.2 193.03,48.9 193.03,50.16 J4.2 193.03,51.44 193.03,52.7 J3.2 | 187.96,29.21 v187.96,40.64 | 187.96,29.21 187.96,19.05 INTENB.16 | IC31.20 172.08,65.41 171.44,66.04 171.44,66.67 C31.1 | IC38.20 172.08,31.11 171.44,31.75 171.44,32.38 C38.1 | IC40.14 156.84,23.5 156.21,24.13 156.21,24.77 C40.1 156.21,26.04 155.57,26.67 v155.57,27.94 | 139.69,60.33 v139.06,59.69 | 139.69,60.33 139.69,61.59 140.33,62.23 C39.1 | 139.69,60.33 139.69,40.64 140.33,40.01 140.33,29.21 140.97,28.57 C46.1 | v186.69,29.21 187.96,29.21 | IC37.20 217.8,31.11 217.16,31.75 217.16,32.38 C37.1 | IC30.20 217.8,61.59 217.16,62.23 217.16,62.87 C30.1 216.53,63.5 216.53,87 217.8,88.27 FIELD.16 217.8,89.53 217.16,90.17 217.16,90.81 C44.1 217.16,92.08 216.53,92.71 216.53,109.86 217.8,111.12 IC12.14 217.8,112.39 217.16,113.03 217.16,113.67 C12.1 | IC17.16 129.53,120.65 128.27,121.92 128.27,128.91 127,130.18 C9.1 127,131.44 125.73,132.72 125.73,141.6 127,142.88 C5.1 | 153.66,128.91 154.94,130.18 C10.1 | 153.66,128.91 152.4,127.64 152.4,121.28 154.94,118.75 C18.1 154.94,117.47 155.57,116.84 155.57,114.3 156.21,113.67 156.21,97.16 C27.1 156.21,95.89 156.21,95.25 156.84,94.61 DAR8-11.16 156.84,93.34 154.94,91.44 154.94,64.14 156.21,62.87 C42.1 | 153.66,128.91 153.66,141.6 154.94,142.88 C6.1 | DMA8-11.16 141.6,94.61 140.97,95.25 140.97,95.89 C8.1 | IC24.20 172.08,99.69 171.44,100.33 171.44,100.97 C24.1 | C19.1 185.41,98.42 185.41,97.79 IC19.14 | IC11.4 193.03,113.03 195.58,115.57 195.58,118.11 IC11.10 | 181.61,120.02 181.61,128.91 180.34,130.18 C7.1
  Top 0.508: 181.61,120.02 182.88,118.75 C11.1 | RA.1 210.18,119.38 208.91,119.38 RL.1 208.28,120.02 208.28,121.92 210.18,123.83 IC8.4 210.18,125.09 206.37,128.91 206.37,138.43 C45.+ | C43X.1 220.97,130.18 219.71,131.44 219.71,132.08 IC8.8 | 181.61,120.02 181.61,98.42 182.88,97.16 R1.2 | 49.52,109.22 45.71,105.41 IC33.16 | 50.16,109.86 49.52,109.22 | 50.16,109.86 50.79,110.49 IC14.3 | 49.52,109.22 49.52,121.28 47.62,121.28 46.35,120.02 IC14.14 | 36.82,140.97 36.82,125.73 43.17,119.38 43.17,118.75 C14.1 | 36.82,140.97 36.82,141.6 38.09,142.88 C2.1 | IC20.20 12.69,105.41 13.33,106.05 13.33,115.57 15.23,117.47 C13.1 | 36.82,140.97 v36.19,140.97 | 80.01,120.65 80.01,114.3 78.73,113.03 IC15.3 | 80.01,120.65 79.37,121.28 73.66,121.28 73.66,120.65 IC15.14 | v73.66,107.31 73.66,105.41 IC21.16 | IC16.16 99.06,118.11 100.33,116.84 100.33,106.68 101.59,105.41 IC22.14 | 92.7,125.09 92.7,141.6 93.98,142.88 C4.1 | 92.7,125.09 96.52,121.28 96.52,118.75 C16.1 | 80.01,120.65 81.91,122.56 91.44,122.56 91.44,123.83 92.7,125.09 | IC34.20 29.84,41.27 29.21,41.91 29.21,42.55 C34.1 | v43.17,15.88 43.17,10.79 SV1.26 43.17,9.53 43.17,8.26 SV1.25 | v33.65,40.64 33.02,40.01 33.02,20.95 35.55,18.41 R2.2 | IC28.20 73.02,74.3 73.02,74.93 72.39,75.56 C28.1 72.39,76.83 73.66,78.11 v73.66,80.01 | C26.1 29.21,75.56 29.84,74.93 29.84,74.3 IC26.20 | v40.63,73.66 40.63,71.75 RS08.2 | 92.7,62.87 92.7,51.44 93.98,50.16 C32.1 93.98,48.9 92.7,47.62 92.7,42.55 96.52,38.73 96.52,31.75 IC36.16 | 92.7,62.87 93.98,64.14 C29.1 | 92.7,62.87 92.7,78.11 93.98,79.38 C25.1 | IC35.20 73.02,41.27 72.39,41.91 72.39,42.55 C35.1
  Top 0.508: IC36.6 109.22,21.59 106.68,19.05 106.68,16.51 IC23.14 | v79.37,40.64 78.73,40.01 78.73,16.51 IC41.16 | v74.29,9.53 76.2,11.43 76.2,13.34 C41.1 | C22.1 99.06,102.23 96.52,99.69 96.52,82.55 IC25.16 | 50.16,109.86 51.43,108.58 v51.43,107.95 | v99.69,147.96 97.15,145.41 IC4.16 | D1.A 236.22,57.15 237.49,58.42 238.12,58.42 RF08A.2 | D6.A 236.85,122.56 238.12,123.83 238.12,124.46 RF08B.2
  Bottom 0.508: C43.1 186.05,16.51 186.69,17.14 187.32,17.14 INTENB.16 | v187.96,40.64 192.4,40.64 J7.2 | DMA0-3.16 142.24,26.04 140.97,27.3 C46.1 141.6,27.94 v155.57,27.94 156.84,29.21 170.18,29.21 | 154.3,63.5 142.87,63.5 141.6,62.23 C39.1 | 154.3,63.5 155.57,62.23 C42.1 156.21,61.59 156.84,61.59 156.84,60.33 DAR4-7.16 | v139.06,59.69 140.97,59.69 DMA4-7.16 | 170.18,29.21 171.44,30.48 IC38.20 | 154.3,63.5 166.37,63.5 167,64.14 170.81,64.14 171.44,64.77 IC31.20 | 170.18,29.21 v186.69,29.21 | C37.1 217.8,33.02 221.61,36.83 221.61,60.33 219.07,60.33 IC30.20 | C17.1 127.63,118.11 128.27,118.75 128.9,118.75 IC17.16 | C9.1 127.63,130.81 128.27,131.44 128.9,131.44 IC9.14 | IC6.16 156.84,144.15 156.21,144.15 155.57,143.51 C6.1 154.94,144.15 152.4,144.15 151.12,142.88 131.44,142.88 130.17,144.15 IC5.14 128.9,144.15 128.27,144.15 127.63,143.51 C5.1 126.36,143.51 118.11,143.51 113.66,147.96 v99.69,147.96 | C18.1 155.57,118.11 156.21,118.75 156.84,118.75 IC18.14 | C10.1 155.57,130.81 156.21,131.44 156.84,131.44 IC10.14 | C8.1 141.6,96.52 142.24,95.89 149.86,95.89 150.49,95.25 153.03,95.25 154.3,96.52 155.57,96.52 C27.1 156.84,96.52 158.11,97.79 170.18,97.79 171.44,99.06 IC24.20 173.99,99.06 176.53,96.52 182.24,96.52 R1.2 183.51,96.52 184.78,96.52 IC19.14 | C7.1 180.97,130.81 181.61,131.44 182.24,131.44 IC7.16 | C11.1 183.51,118.11 184.15,118.75 184.78,118.75 IC11.14 186.05,120.02 187.32,121.28 193.67,121.28 194.94,120.02 IC11.10 196.21,118.75 197.48,117.47 213.36,117.47 | 213.36,117.47 211.45,119.38 RA.1 | 213.36,117.47 216.53,114.3 C12.1 | IC8.8 217.16,132.08 210.18,139.06 207,139.06 C45.+
  Bottom 0.508: C2.1 38.73,143.51 39.36,144.15 40,144.15 IC2.16 | C14.1 43.81,118.11 44.45,118.75 45.08,118.75 IC14.14 | C33.1 43.81,102.87 44.45,103.5 45.08,103.5 IC33.16 | IC3.16 67.94,144.15 67.31,144.15 66.67,143.51 C3.1 65.4,143.51 63.49,141.6 36.19,141.6 | IC1.16 12.06,144.15 11.42,144.15 10.79,143.51 C1.1 10.15,142.88 8.88,141.6 | C20.1 10.79,102.87 11.42,103.5 12.06,103.5 IC20.20 | IC13.3 22.86,113.03 17.78,118.11 IC13.14 17.14,118.75 16.51,118.75 15.87,118.11 C13.1 15.23,118.75 6.98,118.75 6.98,139.7 8.88,141.6 | 36.19,141.6 8.88,141.6 | v36.19,140.97 36.19,141.6 | C15.1 71.75,118.11 72.39,118.75 73.02,118.75 IC15.14 | C4.1 94.61,143.51 95.25,144.15 95.88,144.15 IC4.16 | C16.1 97.15,118.11 97.79,118.75 98.42,118.75 IC16.16 | C21.1 71.75,102.87 72.39,103.5 73.02,103.5 IC21.16 | IC22.14 100.96,103.5 100.33,103.5 99.69,102.87 C22.1 98.42,102.87 95.25,106.05 86.36,106.05 85.09,107.31 v73.66,107.31 73.02,106.68 52.7,106.68 v51.43,107.95 | v43.17,15.88 38.09,15.88 36.19,17.78 R2.2 | v33.65,40.64 31.75,40.64 IC34.20 | v40.63,73.66 31.75,73.66 IC26.20 | C28.1 71.75,76.2 70.48,74.93 64.77,74.93 63.49,76.2 29.84,76.2 C26.1 | IC25.16 95.88,80.64 95.25,80.64 94.61,80.01 C25.1 93.34,80.01 v73.66,80.01 | C32.1 94.61,49.53 95.25,50.16 95.88,50.16 IC32.16 | C29.1 94.61,64.77 95.25,65.41 95.88,65.41 IC29.16 | C36.1 94.61,29.21 95.25,29.84 95.88,29.84 IC36.16 97.15,29.84 102.87,24.13 102.87,20.95 107.31,20.95 108.58,22.23 IC36.6 | C41.1 76.83,13.97 77.47,14.61 78.1,14.61 IC41.16 79.37,15.88 80.64,17.14 100.33,17.14 103.5,13.97 C23.1 104.77,13.97 105.41,14.61 106.04,14.61 IC23.14
  Bottom 0.508: v79.37,40.64 74.93,40.64 IC35.20 | v74.29,9.53 73.02,8.26 44.45,8.26 43.81,7.62 SV1.25
WE\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v112.39,100.33 112.39,98.42 111.76,97.79 IC22.5 111.76,95.25 111.76,90.17 v110.48,88.9 | v148.59,100.33 151.76,103.5 v151.76,139.7 | v42.54,68.58 42.54,66.04 40.63,64.14 RS08.8 | v53.97,70.48 54.6,71.12 v54.6,87.63 | IC43.29 246.38,22.86 246.38,27.3 245.11,28.57 245.11,31.75 246.38,33.02 246.38,44.45 IC42.29 246.38,46.99 246.38,52.7 245.11,53.98 245.11,57.78 245.74,58.42 RF08A.8 | IC45.29 246.38,87.63 245.11,88.9 245.11,97.79 245.74,98.42 245.74,111.12 IC39.29 246.38,113.03 245.11,114.3 245.11,122.56 246.38,123.83 RF08B.8
  Bottom 0.254: v112.39,100.33 113.03,99.69 123.82,99.69 125.09,100.97 147.95,100.97 v148.59,100.33 | v151.76,139.7 152.4,140.34 161.92,140.34 163.19,139.06 165.73,139.06 167,137.79 IC6.5 | v42.54,68.58 44.45,70.48 v53.97,70.48 | v54.6,87.63 97.79,87.63 99.06,88.9 v110.48,88.9
WLS  (via drill 0.61)
  Top 0.254: v140.97,148.59 140.97,127 139.69,125.73 IC9.5 | v204.47,144.15 213.36,135.25 213.36,25.4 211.45,23.5 IC37.4
  Bottom 0.254: v204.47,144.15 198.75,149.86 142.24,149.86 v140.97,148.59 139.06,150.5 15.87,150.5 10.79,145.41 2.54,145.41 2.54,15.88 12.06,6.35 28.57,6.35 29.84,7.62 SV1.15
WLS\  (via drill 0.61)
  Top 0.254: v142.24,128.27 142.24,125.73 IC9.6
  Bottom 0.254: v142.24,128.27 142.87,128.91 160.65,128.91 161.28,129.54 170.81,129.54 171.44,128.91 196.21,128.91 199.38,125.73 199.38,121.28 209.55,121.28 210.18,120.65 212.72,120.65 220.34,113.03 220.34,109.86 219.07,109.86 IC12.13
WRITING  (via drill 0.61)  (2 unrouted)
  Top 0.254: 156.84,135.25 156.21,135.89 156.21,142.24 162.56,142.24 166.37,138.43 166.37,135.89 168.91,133.35 168.91,127 167.63,125.73 IC10.5 | 156.84,135.25 159.38,135.25 159.38,136.53 IC6.2 | v49.52,50.16 49.52,48.26 48.89,47.62 v48.89,11.43 48.89,5.08 24.76,5.08 22.86,6.99 SV1.9 | v82.55,12.06 82.55,12.7 83.81,13.97 IC41.14 | 156.84,135.25 156.21,134.62 156.21,129.54 153.66,127 v153.66,124.46 | v110.48,128.27 107.95,125.73 107.95,123.19 106.04,121.28 97.79,121.28 97.79,106.05 100.33,103.5 100.33,90.17 97.79,87.63 v97.79,76.83 | v87.62,76.2 87.62,18.41 86.36,17.14 86.36,16.51 IC41.13 | IC43.24 259.07,22.86 259.07,27.3 257.81,28.57 257.81,31.75 259.07,33.02 259.07,44.45 IC42.24 259.07,46.99 259.07,52.7 257.81,53.98 257.81,57.78 258.44,58.42 RF08A.18 | IC45.24 259.07,87.63 257.81,88.9 257.81,98.42 258.44,99.06 258.44,111.12 IC39.24 259.07,113.03 257.81,114.3 257.81,122.56 259.07,123.83 RF08B.18
  Bottom 0.254: IC41.14 84.45,14.61 85.72,14.61 IC41.13 | v49.52,50.16 48.89,50.8 41.27,50.8 RS08.18 | v82.55,12.06 81.91,11.43 v48.89,11.43 | v153.66,124.46 152.4,123.19 146.05,123.19 145.41,122.56 136.52,122.56 135.88,123.19 135.88,126.36 133.98,126.36 132.08,128.27 v110.48,128.27 | v97.79,76.83 97.15,76.2 v87.62,76.2

## Text on the board
Bottom: VRS | RS08 | VRS | RS08 | RF08 | VRS
tPlace: RF08 | VRS
tValues: RS08 | VRS | RS08 | VRS